# Repository Ares-0425/PosDog_motor

File README.md:

# PosDog_motor
四脚歩行ロボット「PosDog」のモータードライバプログラムと回路CADデータのレポジトリ
## 動作環境
プログラムはVSCode＋PlatformIO環境で作成しています。
回路CADはKiCADを使用し、JLCPCBでの発注を想定しています。
## ファイル
### プログラム
レポジトリ全体がPlatformIOのプログラムフォルダになっていますが、いじるべきプログラムは"src"フォルダ内に入っています。
- main.cpp  
  メインプログラムファイル。主にSimpleFOC（モーター制御ライブラリ）の設定、SimpleFOC制御ループ、CAN通信で取得した文字列の識別と文字列に応じた動作の実行、キャリブレーション動作の定義、を行っている。
- can.hpp  
  can.cppのヘッダー
- can.cpp  
  can通信用ファイル。設定と受信時のID及び文字列格納。
- dob.hpp  
  dob.cppのヘッダー
- dob.cpp  
  外乱オブザーバーと、外乱オブザーバーを考慮したトルク制御と角度制御の指令値出力。
- identification.hpp  
  identification.cppのヘッダー
- identification.cpp  
  システム同定を一瞬やろうとした時の残骸
### 回路
"drv8311"フォルダ内に入っています。
- drv8311.kicad_pro  
  kicadプロジェクトファイル
- drv8311.kicad_sch  
  kicad回路図ファイル
- drv8311.kicad_pcb  
  kicadPCBファイル
- production
  - drv8311.zip  
    JLCPCB発注用ファイル
## 基本の使いかた
プログラムを書き込む脚に合わせて、main.cppの"#define LEG"の数字を変更する。

## KiCad design drv8311/drv8311.kicad_pcb

Parts:
BOOT1: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
C1: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C8, C10, C12: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 10u; CP_Radial_D5.0mm_P2.00mm
C6, C9: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C7: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 470u; not fitted
J1: VH_3B; JST_VH_B3P-VH_1x03_P3.96mm_Vertical
J2: SH_6B; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
J3: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J4: SH_4B; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; not fitted
J5: XH_2B; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: ZH_2B; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J7, J8: PH_2B; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J9: PH_3B; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J10: ZH_3B; JST_ZH_S03B
Power1: OSHR1608; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1, R4: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R5: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 75; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 540; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
Reset1: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
Status1: OSYG1608; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
TP1: TestPoint
U1: DRV8311HRRWR; WQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm
U2: ESP32-WROOM-E; ESP32-WROOM-32UE
U3: TJA1441AT; SO-8_3.9x4.9mm_P1.27mm
U4: AZ1117-3.3; SOT-223-3_TabPin2
photo1: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
5V: C6.1, C8.1, C9.1, C12.2, J2.5, J3.4, J4.3, J5.1, J9.2, J10.1, U1.7 (VIN_AVDD), U3.3 (VCC), U4.3 (VI), photo1.2 (A)
AVDD: C1.1, C2.1, C7.1, C10.1, R2.2, R5.2, R7.1, U1.2 (CSAref), U1.17 (AVDD), U2.2 (3V3), U3.5 (VIO), U4.2 (VO)
Brake: J9.1, U2.16 (MTCK/GPIO13/ADC2_CH4)
CLK: J2.1, U2.30 (GPIO18)
CRX: U2.26 (ADC2_CH0/GPIO4), U3.4 (RXD)
CTS: BOOT1.2, C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, J2.6, J3.5, J3.6, J4.4, J5.2, J6.2, J9.3, J10.3, Power1.1 (K), R1.1, R4.1, Reset1.1, Status1.1 (K), U1.9 (PGND), U1.16 (AGND), U1.25 (ThermalPAD), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND_THERMAL), U3.2 (GND), U3.8 (S), U4.1 (GND)
CTX: U2.27 (GPIO16), U3.1 (TXD)
INHA: U1.15 (INHA), U2.11 (DAC_2/ADC2_CH9/GPIO26)
INHB: U1.14 (INHB), U2.12 (ADC2_CH7/GPIO27)
INHC: U1.13 (INHC), U2.13 (MTMS/GPIO14/ADC2_CH6)
INLA: U1.18 (INLA), U2.10 (DAC_1/ADC2_CH8/GPIO25)
INLB: U1.19 (INLB), U2.9 (32K_XN/GPIO33/ADC1_CH5)
INLC: U1.20 (INLC), U2.8 (32K_XP/GPIO32/ADC1_CH4)
MISO: J2.2, U2.31 (GPIO19)
MOSI: J2.3, U2.37 (GPIO23)
unnamed: BOOT1.1, R3.2
unnamed: J1.1, U1.10 (OUTA)
unnamed: J1.2, U1.11 (OUTB)
unnamed: J1.3, U1.12 (OUTC)
unnamed: J7.1, J8.1, U3.7 (CANH)
unnamed: J7.2, J8.2, U3.6 (CANL)
unnamed: Power1.2 (A), R7.2
unnamed: R8.2, Status1.2 (A)
unnamed: C3.2, U1.6 (CP)
unnamed: R4.2, U1.21 (GAIN)
unnamed: R1.2, U1.23 (MODE)
unnamed: R5.1, Reset1.2, U2.3 (EN/CHIP_PU)
unnamed: R3.1, U2.25 (GPIO0/BOOT/ADC2_CH1)
unnamed: R9.1, photo1.1 (K)
RTS: J3.1
RX: J3.3, U2.34 (U0RXD/GPIO3)
SOA: U1.5 (SOA), U2.6 (GPIO34/ADC1_CH6)
SOB: U1.4 (SOB), U2.5 (SENSOR_VN/GPIO39/ADC1_CH3)
SOC: U1.3 (SOC), U2.4 (SENSOR_VP/GPIO36/ADC1_CH0)
Status: R8.1, U2.28 (GPIO17)
TX: J3.2, U2.35 (U0TXD/GPIO1)
VDD: C3.1, C4.1, C5.1, C11.1, J6.1, U1.8 (VM)
nCS: J2.4, U2.29 (GPIO5)
nFAULT: R2.1, U1.1 (nFAULT), U2.36 (GPIO22)
nSLEEP: U1.24 (nSLEEP), U2.33 (GPIO21)
photo: J10.2, R9.2, U2.7 (GPIO35/ADC1_CH7)

Notes on the sheet:
MODE：そのままGND→6PWMOCP9A、47kΩからGND→6PWMOCP5A、未接続→3PWMOCP9A、AVDD→3PWMOCP5A SLEW：そのままGND→35V/us、47kΩからGND→75V/us、未接続→180V/us、AVDD→230V/us GAIN：そのままGND→0.25V/A、47kΩからGND→0.5V/A、未接続→1V/A、AVDD→2V/A

Board: 2 copper layers, 50.0 x 50.0 mm, 41 parts (9 on the bottom side), 40 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3

File drv8311/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"BOOT1, RESET1",SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,2,SW_Push,
C1,0805,1,1u,
"C10, C12, C2, C3, C4, C8",0805,6,0.1u,
C5,CP_Radial_D5.0mm_P2.00mm,1,10u,
"C6, C9",1210,2,10u,
C7,0805,1,22u,
J1,JST_VH_B3P-VH_1x03_P3.96mm_Vertical,1,VH_3B,
J10,JST_ZH_S03B,1,ZH_3B,
J2,JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal,1,SH_6B,
J3,PinHeader_1x06_P2.54mm_Vertical,1,Conn_01x06_Pin,
J5,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,XH_2B,
J6,JST_VH_B2P-VH_1x02_P3.96mm_Vertical,1,ZH_2B,
"J7, J8",JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,2,PH_2B,
J9,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,1,PH_3B,
PHOTO1,0603,1,LED,
POWER1,0603,1,OSHR1608,
"R1, R4",0805,2,47k,
R2,0805,1,5.1k,
"R3, R5",0805,2,10k,
R7,0805,1,220,
R8,0805,1,75,
R9,0805,1,540,
STATUS1,0603,1,OSYG1608,
U1,WQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm,1,DRV8311HRRWR,
U2,ESP32-WROOM-32UE,1,ESP32-WROOM-E,
U3,SO-8_3.9x4.9mm_P1.27mm,1,TJA1441AT,
U4,SOT-223-3_TabPin2,1,AZ1117-3.3,

## Commit log

2026-04-26 モーターコントローラファイル追加
2026-04-26 KiCADファイル追加、readme更新
2026-04-26 redme更新
